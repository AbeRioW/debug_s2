# Keil uVision project ACH512.uvprojx, settings and files
target project (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: ACH512 +hex
  c flags: oTime=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_CARDANO
  c include: .\ACH512\driver;.\ACH512\system;.\APP;.\CMSIS\Include;.\COMMON;.\ACH512\foundation\core;.\ACH512\foundation\core\aes;.\ACH512\foundation\core\ed25519-donna;.\ACH512\foundation\ecdsa;.\ACH512\foundation\hash;.\ACH512\foundation\hrng;.\ACH512\crypto
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group system
    ./ACH512/system/: startup.s system_ach512.c
  group driver
    ./ACH512/driver/: uart.c usb.c usb_app.c usb_desc.c webusb.c eflash.c
  group common
    ./COMMON/: common.c
  group app
    ./APP/: main.c seed.c
  group doc
    ./: Abstratct.txt
  group foundation
    ./ACH512/foundation/core/: address.c base58.c bignum.c bip32.c bip39.c bip44.c blake2b.c blake256.c curves.c ecdsa.c groestl.c hasher.c hmac.c hmac_drbg.c memzero.c nist256p1.c pbkdf2.c rand.c rfc6979.c ripemd160.c secp256k1.c sha2.c sha3.c
    ./ACH512/foundation/core/aes/: aes_modes.c aescrypt.c aeskey.c aestab.c aestst.c
    ./ACH512/foundation/core/ed25519-donna/: curve25519-donna-32bit.c curve25519-donna-helpers.c curve25519-donna-scalarmult-base.c ed25519.c ed25519-donna-32bit-tables.c ed25519-donna-basepoint-table.c ed25519-donna-impl-base.c ed25519-keccak.c ed25519-sha3.c modm-donna-32bit.c
    ./ACH512/foundation/ecdsa/: ecdsa_params.c ecdsa_20171106.lib pki_20170406.lib rsa_20171106.lib
    ./ACH512/foundation/hash/: sha1_20171106.lib sha256_20171106.lib
    ./ACH512/foundation/hrng/: hrng_20171106.lib
  group crypto
    ./ACH512/crypto/: cx_derive.c cx_hash.c cx_sign.c
software components: CMSIS:CORE 5.6.0
